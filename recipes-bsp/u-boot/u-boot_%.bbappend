FILESEXTRAPATHS:prepend := "${THISDIR}/patches:"
SRC_URI += " file://0001-Add-U-Boot-environment-variable.patch "